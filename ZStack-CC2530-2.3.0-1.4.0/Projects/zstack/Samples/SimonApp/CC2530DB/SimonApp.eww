<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SimonApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>SimonApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SimonApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SimonApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>SimonApp</project>
        <configuration>CoordinatorEB-Pro</configuration>
      </member>
      <member>
        <project>SimonApp</project>
        <configuration>RouterEB-Pro</configuration>
      </member>
      <member>
        <project>SimonApp</project>
        <configuration>EndDeviceEB-Pro</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


